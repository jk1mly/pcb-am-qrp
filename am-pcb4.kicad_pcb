# Repository jk1mly/pcb-am-qrp

File README.md:

ハムフェアでPRUGブースで基板を頒布したので、

https://github.com/Packet-Radio-Users-Group/QRP_AM_Transceiver_JK1MLY

に引っ越しました

ここにあるのは古いデータになるので注意して下さい

## KiCad design am-pcb4.kicad_pcb

Parts:
C1, C2: 100u; CP_Radial_D7.5mm_P2.54mm_dot
C3, C4, C5, C6, C7, C8, C9, C11, C21, C33, C52, C53, C55, C56, C58, C60, C61, C71, C74, C78, C80, C91, C92, C93: 0.1u; C_Disc_P2.54mm
C12, C14, C16, C22, C31, C32, C41, C62, C73, C79, C86: 1000p; C_Disc_P2.54mm
C13, C36, C37, C38: 100p; C_Disc_P2.54mm
C15, C23, C24, C25, C63, C65, C66, C67, C72: 33p; C_Disc_P2.54mm
C26, C68: 15p; C_Disc_P2.54mm
C34, C35: 150p; C_Disc_P2.54mm
C39: 1u; C_Disc_P2.54mm
C42, C43, C44, C82, C83, C84: 220p; C_Disc_P2.54mm
C45, C46, C47, C48: 150p; C_Disc_P2.54mm; not fitted
C51, C54, C57, C59, C75, C76, C77, C81: 10u; C_Disc_P5.12mm
C64, C94, C95, C96: 10p; C_Disc_P2.54mm; not fitted
C69: C_Trim; C_TRIM_P6.00mm; not fitted
C85: 10p; C_Disc_P2.54mm
D21: 1SV161; D_T-1_P5.08mm_Horizontal; not fitted
D81, D82: 1N60; D_A-405_P2.54mm_Vertical_AnodeUp
D91, D92: LED; LED_D3.0mm
D201: 1N4148; D_A-405_P2.54mm_Vertical_AnodeUp
IC51: UTC7642; TO-92_Inline_Wide
J91, J92: Conn_Coaxial; RF_SMA_Vertical_5-1814832-1; not fitted
J93: AudioJack4; Jack_3.5mm_GB-35J-4CW-BM; not fitted
J94: AudioJack2_Ground; Jack_3.5mm_CUI_SJ1-3525N_Horizontal; not fitted
J95: AudioJack3; Jack_3.5mm_GB-35J-3CWS-BM; not fitted
J101, J103: Univ_03x05; univ_03x05
J102: Univ_03x02; univ_03x03
J104: Univ_04x08; univ_04x08
J201, J202: AudioPlug4
K91: Y14x-1C-xxDS; Relay_SPDT_HsinDa_Y14; not fitted
K201: Y14x-1C-xxDS; Relay_SPDT_HsinDa_Y14
L11, L71: 100u; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
L21, L61: 10u; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical; not fitted
L22: 100u; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical; not fitted
L41, L42, L81, L82: 15u; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
LS201: Speaker
MK201: Microphone
Q11: BF256B; TO-92_Inline_Wide
Q21, Q31, Q61, Q71: 2SC1959; TO-92_Inline_Wide
Q201: 2SA1015; TO-92_Inline_Wide
R11, R12, R15, R21, R31, R35, R61: 100; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R13, R75: 22k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R14, R53, R76: 100k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R22, R23, R62, R63, R71: 47k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R24: 100; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical; not fitted
R25: 1k; Potentiometer_1; not fitted
R26: 10k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical; not fitted
R27, R64: 2.2k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R28: 0; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical; not fitted
R29: 0; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R32: 15k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R33: 10k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R34: 220; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R51: 3.3k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R52, R74: 10; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R54: 10k; Potentiometer_1
R72: 6.8k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R73: 22; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R81: 1M; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical; not fitted
R91, R92, R201: 1k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
R202: 4.7k; R_Axial_DIN0207_L6.3mm_D2.2mm_P2.54mm_Vertical
SW201: SW_SPDT_MSM
SW202: SW_Push
T11, T71: 7S25; coil_7mm
T21, T61: 7T25; coil_7mm
T31: 7S1R0; coil_7mm
T41, T42: 7S1R0; coil_7mm; not fitted
T62: 7T25; coil_7mm; not fitted
T91: 7T50; coil_7mm; not fitted
TP2, TP5, TP56, TP91, TP92, TP93, TP94, TP95, TP96, TP97, TP98, TP99, TP118, TP119: TestPoint; TestPoint_pad_only_Drill1.0mm
TP3, TP4, TP9, TP11, TP12, TP19, TP21, TP31, TP32, TP33, TP34, TP41, TP42, TP44, TP45, TP51, TP52, TP55, TP57, TP59, TP61, TP62, TP71, TP73, TP74, TP84, TP85, TP86, TP89, TP101, TP102, TP103, TP104, TP105, TP106, TP107, TP108, TP109, TP110, TP111, TP112, TP113, TP114, TP115, TP116, TP117: TestPoint; TestPoint_Loop_D2.50mm_Drill1.0mm
TP87, TP88: TestPoint; TestPoint_Loop_D3.80mm_Drill2.5mm
U41: CF-455; CF-3P; not fitted
U51, U71: LM386; DIP-8_W7.62mm_Socket
U91: Microphone; Mic_CMA-4544PF-W; not fitted
X21: 27.000M; Crystal_HC49-U_Vertical
X61: 28.375M; Crystal_HC49-U_Vertical
Z1, Z2, Z3, Z4: TestPoint; TestPoint_Drill3mm

Connections:
+9V: C1.1, C3.1, C4.1, C5.1, C6.1, C11.1, C21.1, C33.1, C92.1, R11.1, R21.1, R24.1, R31.1, R52.1, R91.1, TP2.1, TP3.1
+9VA: C2.1, C7.1, C8.1, C9.1, C61.1, C71.2, R61.1, R71.1, R74.1, R75.1, R92.1, TP4.1, TP5.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C15.2, C16.2, C21.2, C22.1, C25.2, C26.2, C31.2, C32.2, C33.2, C39.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C52.1, C53.2, C54.2, C57.2, C58.1, C60.1, C61.2, C62.1, C66.2, C67.2, C68.2, C69.2, C71.1, C74.2, C76.2, C77.2, C79.2, C80.2, C82.2, C83.2, C84.2, C86.2, C91.2, C92.2, C93.2, D21.2 (A), D82.2 (A), D91.1 (K), D92.1 (K), IC51.1 (GND), J91.1 (G), J92.1 (G), J94.G, J95.S, J101.15, J102.4, J102.6, J102.8, J103.11, J104.1, J104.8, K91.4, Q71.1 (E), R14.2, R15.1, R23.1, R25.3, R27.1, R33.1, R34.1, R54.1, R63.1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
unnamed: C12.1, L11.1, R11.2, R13.1
unnamed: C13.1, R12.1
unnamed: C22.2, R21.2, R22.1, R28.1, R29.1
unnamed: C26.1, L21.1, X21.1
unnamed: C36.1, TP32.1
unnamed: C37.1, R35.1
unnamed: C38.2, TP33.1
unnamed: C41.1, C95.1, TP44.1
unnamed: C41.2, C42.1, C94.1, L41.1
unnamed: C43.1, L41.2, L42.1
unnamed: C44.1, L42.2, TP45.1
unnamed: C51.1, U51.1 (GAIN)
unnamed: C51.2, U51.8 (GAIN)
unnamed: C55.1, TP55.1
unnamed: C56.2, R54.3
unnamed: C59.1, C60.2, U51.5
unnamed: C59.2, TP56.1, TP57.1
unnamed: C68.1, L61.1, X61.1
unnamed: C69.1, L61.2
unnamed: C73.1, TP71.1
unnamed: C75.1, C80.1, R73.2, U71.5
unnamed: C75.2, L71.2, R73.1
unnamed: C78.1, R75.2, TP73.1
unnamed: C81.1, U71.1 (GAIN)
unnamed: C81.2, U71.8 (GAIN)
unnamed: C82.1, L81.1, TP84.1
unnamed: C83.1, L81.2, L82.1
unnamed: C84.1, L82.2, TP85.1
unnamed: C85.1, TP86.1
unnamed: C93.1, R51.1, TP51.1
unnamed: D21.1 (K), L21.2, L22.2
unnamed: C85.2, D81.2 (A), D82.1 (K)
unnamed: C86.1, D81.1 (K), R81.2, TP87.1
unnamed: C91.1, D91.2 (A), R91.2, TP52.1
unnamed: D92.2 (A), R92.2
unnamed: D201.1 (K), K201.4, SW201.2
unnamed: D201.2 (A), K201.3, Q201.2 (C)
unnamed: C55.2, IC51.2 (IN), R53.2
unnamed: C56.1, C58.2, IC51.3 (OUT), R51.2, R53.1
unnamed: J91.2 (S), TP93.1
unnamed: J92.2 (S), K91.5, K91.6, TP91.1
unnamed: J93.R2, TP98.1
unnamed: J93.S, TP97.1
unnamed: J93.T, TP99.1
unnamed: J94.S, TP95.1
unnamed: J94.T, TP96.1
unnamed: J95.T, TP94.1
unnamed: J102.1, K91.2
unnamed: J102.2, J102.5, K91.3
unnamed: J102.3, K91.1
unnamed: J201.R2, SW202.2
unnamed: J201.T, LS201.2
unnamed: K201.5, K201.6
unnamed: L22.1, R26.2
unnamed: C13.2, L11.2, Q11.3 (D)
unnamed: C14.2, Q11.1 (G), R13.2, R14.1
unnamed: C16.1, Q11.2 (S), R15.2
unnamed: C24.1, Q21.3 (B), R22.2, R23.2, X21.2
unnamed: C23.2, Q21.2 (C), T21.3 (PR2)
unnamed: C24.2, C25.1, Q21.1 (E), R27.2
unnamed: C36.2, C37.2, Q31.3 (B), R32.2, R33.2
unnamed: C34.2, C35.2, Q31.2 (C), T31.3 (PR2)
unnamed: C38.1, C39.1, Q31.1 (E), R34.2
unnamed: C65.1, Q61.3 (B), R62.2, R63.2, X61.2
unnamed: C63.2, C64.1, Q61.2 (C), T61.3 (PR2)
unnamed: C65.2, C67.1, Q61.1 (E), R64.2
unnamed: C73.2, Q71.3 (B), R71.2, R72.2
unnamed: C72.1, Q71.2 (C), T71.3 (PR1)
unnamed: R12.2, TP12.1
unnamed: R24.2, R25.1
unnamed: R25.2, R26.1
unnamed: R35.2, TP31.1
unnamed: C14.1, C15.1, T11.1 (PR1)
unnamed: T11.5 (S2), TP11.1
unnamed: R29.2, T21.2 (PM)
unnamed: C23.1, R28.2, T21.1 (PR1)
unnamed: T21.5 (S2), TP21.1
unnamed: C32.1, R31.2, R32.1, T31.2 (PM)
unnamed: C31.1, C34.1, C35.1, T31.1 (PR1)
unnamed: T31.5 (S2), TP34.1
unnamed: C45.1, C46.1, C95.2, C96.1, T41.1 (PR1)
unnamed: C47.1, C48.1, C94.2, C96.2, T42.1 (PR1)
unnamed: C62.2, R61.2, R62.1, T61.2 (PM)
unnamed: C63.1, T61.1 (PR1)
unnamed: T61.5 (S2), TP61.1
unnamed: C64.2, C66.1, T62.1 (PR1)
unnamed: T62.5 (S2), TP62.1
unnamed: C74.1, L71.1, T71.2 (PM)
unnamed: C72.2, T71.1 (PR2)
unnamed: T71.4 (S2), TP74.1
unnamed: TP41.1, U41.1 (IN)
unnamed: TP42.1, U41.3 (OUT)
unnamed: C52.2, R54.2, U51.3 (+)
unnamed: C57.1, U51.7 (BYPASS)
unnamed: C53.1, C54.1, R52.2, U51.6 (V+)
unnamed: C78.2, C79.1, R76.2, U71.3 (+)
unnamed: C77.1, U71.7 (BYPASS)
unnamed: C76.1, R74.2, U71.6 (V+)
unnamed: TP92.1, U91.2 (+)

Notes on the sheet:
Reference circuit
additional BPF
Jumper TP61-TP71 TX LO signal
L-ch R-ch GND MIC
Reserve circuit
50M 7T1R0 300p 1.7M 16.9344*3 -16.384*3 = 1.6512 28M 7T1R0 370p 1.4M 28.375-27.000 = 1.375
D21 1SV161 1T32 1SV136A
CTIA 4pin
Audio output
Jumper TP74-TP84 TX RF signal
DATA
RX Input
R73 extremely low power 1k normal about 10mW 22
Jumper TP45-TP55 IF signal
Audio input
Drill=3.2mm Wire=0.4mm Length=5.12mm r=1.8-1.9 Turn 9 = 153-169n Turn 11 = 230-253n Turn 13 = 321-353n
2M chebyshev 3300p,4.7u,4700p,4.7u,3300p 3M chebyshev 2200p,3.3u,3300p,3.3u,2200p 2M butterworth 1000p,6.8u,3300p,6.8u,1000p 3M butterworth 680p,4.7u,2200p,4.7u,680p
Jumper TP12-TP32 RX RF signal
Jumper TP21-TP31 RX LO signal
Drill=3.2mm Wire=0.2mm Length=2.54mm r=1.7-1.8 Turn 7 = 136-150n Turn 9 = 226-248n Turn 11 = 338-371n
PTT
TX output
YAESU 4pin
50M 7T50 12p 2SC1923 16.9344M x 3 28M 7T25 33p 2SC1959 28.375M 7M 7T7 100p 2SC1959 7.181M
RF Detector for TEST (If you have only a tester)
35M chebyshev 150p,330n,330p,330n,150p 60M chebyshev 82p,150n,120p,150n,82p 35M butterworth 56p,330n,180p,330n,56p 60M butterworth 33p,220n,100p,220n,33p
50M 7T50 10p 2SC1923 16.384M x 3 28M 7T25 33p 2SC1959 27.000M
Jumper TP51-TP52 IC's power

Board: 2 copper layers, 99.7 x 97.8 mm, 226 parts (0 on the bottom side), 97 nets.
